# Keil uVision project adc_scan_jqr_sw.uvprojx, settings and files
target adc_scan_jqr_sw_Release (6130001::V6.13.1::.\ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adc_scan_jqr_sw +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\driver\inc;..\..\..\..\driver\src;..\common;..\driver\inc;..\driver\src;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../common/: interrupts_hc32l13x.c system_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: adc.c bgr.c ddl.c dmac.c gpio.c sysctrl.c uart.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
